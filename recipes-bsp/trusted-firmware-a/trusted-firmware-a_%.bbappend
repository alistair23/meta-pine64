DEPENDS:append:rk3399 = " gcc-arm-none-eabi-native"

COMPATIBLE_MACHINE:append:a64 = "|a64"
COMPATIBLE_MACHINE:append:h6 = "|h6"
COMPATIBLE_MACHINE:append:rk3399 = "|rk3399"
