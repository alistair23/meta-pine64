FILESEXTRAPATHS:prepend:pinenote-a55 := "${THISDIR}/${PN}-pinenote-a55:"
