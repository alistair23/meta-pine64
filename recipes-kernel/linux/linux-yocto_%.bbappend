COMPATIBLE_MACHINE:append:pine-h64 = "|pine-h64"

