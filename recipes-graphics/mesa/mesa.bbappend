PACKAGECONFIG:append:h6 = " kmsro panfrost"
PACKAGECONFIG:append:pine-pinetab2 = " kmsro panfrost"
