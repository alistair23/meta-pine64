PACKAGECONFIG_append_h6 = " kmsro panfrost"

