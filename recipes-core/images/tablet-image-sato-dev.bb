
# start with sato-dev
require recipes-sato/images/core-image-sato-dev.bb

# add extra tablet packages
require tablet-image-dev.bb
